# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000)  IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RT_USING_ARMLIBC, RT_USING_LIBC, HC32F460, __DEBUG, USE_DDL_DRIVER, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: rt-thread\libcpu\arm\cortex-m4;board\config;libraries\hc32f460_ddl\drivers\hc32_ll_driver\inc;rt-thread\components\drivers\include;libraries\hc32f460_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\netdev\include;packages\at_device\inc;lwrb\src\include;rt-thread\components\drivers\include;rt-thread\components\net\sal\impl;packages\at_device\class\ml307;rt-thread\components\drivers\include;packages\FlashDB-v2.1.0\inc;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\include;packages\pahomqtt\MQTTPacket\src;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;board\config\usb_config;applications;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;packages\syswatch\inc;rt-thread\components\utilities\ulog;rt-thread\components\finsh;rt-thread\components\fal\inc;board;rt-thread\components\net\sal\include;libraries\hc32_drivers\drv_flash;.;board\ports\fal;rt-thread\components\net\at\include;rt-thread\components\net\sal\include\socket;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\libc\posix\io\poll;rt-thread\components\dfs\dfs_v1\include;lwrb\src\include\lwrb;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\libc\compilers\common\include;board\ports;rt-thread\components\drivers\spi\sfud\inc;libraries\hc32f460_ddl\drivers\cmsis\Include;rt-thread\components\libc\posix\io\epoll;rt-thread\components\utilities\resource;rt-thread\components\net\at\at_socket;rt-thread\components\libc\posix\io\eventfd;packages\pahomqtt\MQTTClient-RT;libraries\hc32_drivers;rt-thread\components\libc\posix\ipc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: uart_test.c params.c xtal32_fcm.c flash_param.c main.c rs485.c
  group AT
    rt-thread/components/net/at/src/: at_client.c at_cli.c at_utils.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device/class/ml307/: at_device_ml307.c at_socket_ml307.c
    packages/at_device/src/: at_device.c
    packages/at_device/samples/: at_sample_ml307.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: board.c board_config.c
    board/ports/: drv_spi_flash.c
    libraries/hc32f460_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
    libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_irq.c drv_spi.c drv_usart.c drv_wdt.c
    libraries/hc32_drivers/drv_flash/: drv_flash_f4.c
  group Fal
    rt-thread/components/fal/src/: fal_partition.c fal_flash.c fal_rtt.c fal.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group FAL
    board/ports/fal/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh_file.c msh_parse.c msh.c shell.c
  group FlashDB
    packages/FlashDB-v2.1.0/src/: fdb_cmd.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c fdb.c fdb_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/hc32f460_ddl/drivers/hc32_ll_driver/src/: hc32_ll_interrupts.c hc32_ll_efm.c hc32_ll_aos.c hc32_ll_dma.c hc32_ll_tmr0.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll.c hc32_ll_rmu.c hc32_ll_spi.c hc32_ll_utility.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c hc32_ll_usart.c hc32_ll_clk.c hc32_ll_fcg.c hc32_ll_pwc.c
    libraries/hc32f460_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group lwrb
    lwrb/src/lwrb/: lwrb.c
  group paho-mqtt
    packages/pahomqtt/MQTTClient-RT/: paho_mqtt_pipe.c
    packages/pahomqtt/MQTTPacket/src/: MQTTPacket.c MQTTSubscribeServer.c MQTTSubscribeClient.c MQTTConnectServer.c MQTTConnectClient.c MQTTUnsubscribeClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTUnsubscribeServer.c MQTTSerializePublish.c
    packages/pahomqtt/samples/: mqtt_sample.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group syswatch
    packages/syswatch/src/: syswatch.c syswatch_test.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
